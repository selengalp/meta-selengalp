FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://k3s.service"